# Provide 'open-iscsi' as an alternative package name
# This allows referencing the package as 'open-iscsi' in IMAGE_INSTALL
RPROVIDES:${PN} += "open-iscsi"
