DESCRIPTION = "Tegra demo base image"

require gbear-image-common.inc
